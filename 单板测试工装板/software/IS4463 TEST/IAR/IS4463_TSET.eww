<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\IS4463_TEST.ewp</path>
    </project>
    <batchBuild />
</workspace>
