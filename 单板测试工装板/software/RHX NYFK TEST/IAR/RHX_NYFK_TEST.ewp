# IAR project RHX_NYFK_TEST.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L052R8 STM8L052R8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L05X_HD_VL
  ICCSTM8.CCIncludePath2: ..\App\inc; ..\Dirver\inc; ..\Lib\inc; ..\User
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.hex
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group APP
    ../App/src/: RS485.c TestItems.c
  group DRIVER
    ../Dirver/src/: Adc.c Clk.c CRC16.c Delay.c ht24lc32.c key.c led.c Lora.c LoraSpiGpio.c usart.c ValvePro.c
  group Lib
    ../Lib/src/: stm8l15x_adc.c stm8l15x_clk.c stm8l15x_exti.c stm8l15x_gpio.c stm8l15x_spi.c stm8l15x_usart.c
  group USER
    ../User/: main.c readme.txt stm8l15x_conf.h stm8l15x_it.c
    ../Lib/inc/: stm8l15x.h
