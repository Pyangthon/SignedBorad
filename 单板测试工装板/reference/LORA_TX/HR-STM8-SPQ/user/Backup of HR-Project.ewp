# IAR project Backup of HR-Project.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: UnspecifiedSTM8 STM8 - Unspecified
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L15X_MD
  ICCSTM8.CCIncludePath2: C:\Users\Administrator\Desktop\HR-STM8-SPQ\Libraries\STM8L15x_StdPeriph_Driver\inc; C:\Users\Administrator\Desktop\HR-STM8-SPQ\Project\user-mudule; C:\Users\Administrator\Desktop\HR-STM8-SPQ\Project\inc
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group lib
    ../Libraries/STM8L15x_StdPeriph_Driver/src/: stm8l15x_gpio.c stm8l15x_usart.c
  group system
    ../Project/src/: stm8_interrupt_vector.c stm8l15x_it.c
  group user
    ./: main.c
